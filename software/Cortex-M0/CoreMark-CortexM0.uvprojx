# Keil uVision project CoreMark-CortexM0.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.4.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M0") CLOCK(12000000) ESEL ELITTLE
  output: CoreMark-CortexM0
  AfterMake: C:\Keil_v5\ARM\ARMCC\bin\fromelf.exe Objects\*.axf --vhx --32x1 --output ./output/code.hex
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c misc: -DITERATIONS=1
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x80000
  link misc: -O3
  group Source Group 1
    ./src/: driver.c driver.h core_list_join.c core_main.c core_matrix.c core_state.c core_util.c coremark.h
    ./src/simple/: core_portme.c core_portme.h
software components: CMSIS:CORE 5.1.2, Device:Startup 1.0.1
